# Keil uVision project keil_led.uvprojx, settings and files
target keil_led (ARM-ADS)
  device: STM32L053R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: keil_led
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L053xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32L0xx/Include
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_tim_ex.c stm32l0xx_hal.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_gpio.c stm32l0xx_hal_tim.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_flash_ramfunc.c
  group Application/User
    ../Src/: stm32l0xx_it.c main.c stm32l0xx_hal_msp.c
  group Application/MDK-ARM
    ./: startup_stm32l053xx.s
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
software components: CMSIS:CORE 4.1.0
